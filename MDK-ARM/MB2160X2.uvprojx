# Keil uVision project MB2160X2.uvprojx, settings and files
target MB2160X2 (ARM-ADS)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: MB2160X2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../../G0_COMMON/app_timer;../../G0_COMMON/cmd_consumer;../../G0_COMMON/gpio_input;../../G0_COMMON/gpio_output;../../G0_COMMON/ramp;../../G0_COMMON/TMC-API/ic/TMC2160;../../G0_COMMON/TMC2160A;../../G0_COMMON/ui;../../G0_COMMON/xAt24Cxx;../../G0_COMMON/xCRC16;../../G0_COMMON/xIIC_IO;../../G0_COMMON/xMisc;../../G0_COMMON/xRingBuffer;../../G0_COMMON/xRs485Dev;../../G0_COMMON/xUartDev;../Core/Src/board;../Core/Src/task;../../G0_COMMON/usr_log;..\Core\Src\ui_max;..\..\G0_COMMON\disk;..\..\G0_COMMON\stm_flash
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group usr/board
    ../Core/Src/board/: board.c
  group usr/task
    ../Core/Src/task/: led_flash.c task.c
  group usr/app_timer
    ../../G0_COMMON/app_timer/: app_timer.c thread_delay.c
  group usr/cmd_consumer
    ../../G0_COMMON/cmd_consumer/: cmd_consumer.c
  group usr/uartdev
    ../../G0_COMMON/xUartDev/: uartDev.c
  group usr/rs485
    ../../G0_COMMON/xRs485Dev/: rs485Dev.c
  group usr/ringbuff
    ../../G0_COMMON/xRingBuffer/: ring_buffer.c
  group usr/ramp
    ../../G0_COMMON/ramp/: myRamp.c rampCmd.c
  group usr/gpio
    ../../G0_COMMON/gpio_input/: input.c inputCmd.c
    ../../G0_COMMON/gpio_output/: output.c outputCmd.c
  group usr/at24cxx
    ../../G0_COMMON/xAt24Cxx/: at24cxx.c
  group usr/iic_io
    ../../G0_COMMON/xIIC_IO/: IIC_IO.c
  group usr/crc16
    ../../G0_COMMON/xCRC16/: crc16.c
  group usr/misc
    ../../G0_COMMON/xMisc/: gpioDecal.c misc.c
  group usr/TMC_API
    ../../G0_COMMON/TMC-API/ic/TMC2160/: TMC2160.c
  group usr/tmc2160a_dev
    ../../G0_COMMON/TMC2160A/: TMC2160A_Cmd.c TMC2160A_DEV.c
  group usr/ui
    ../../G0_COMMON/ui/: ui.c ui_numBox.c ui_page.c ui_pic.c ui_txtBox.c ui_txtBox_pic.c
  group usr/ui/instance
    ../Core/Src/ui_max/: ui_machine.c ui_cb_instance.c
  group usr/log
    ../../G0_COMMON/usr_log/: user_log.c
  group usr/stm_flash
    ../../G0_COMMON/stm_flash/: stm_flash.c stm_flash_Cmd.c
  group usr/disk
    ../../G0_COMMON/disk/: disk.c
software components: CMSIS:CORE 4.3.0
